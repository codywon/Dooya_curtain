# Keil uVision project sac_dbg.uvproj, settings and files
target sac_dbg (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: sac_dbg
  AfterMake: fromelf --bin --output=output_sac_dbg\sac_dbg.bin output_sac_dbg\sac_dbg.axf
  AfterMake: ..\..\..\arch\img_pkg_win.exe -i output_sac_dbg\sac_dbg.bin -o output_sac_dbg\sac_dbg.img -t stm32f1
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER __NO_EMBEDDED_ASM  AYLA_KEIL DEMO_IMG_MGMT AYLA_HOST_OTA DEMO_SCHED_LIB DEMO_TIME_LIB AYLA_SCHED AYLA_TIME DEMO_CONF AYLA_CONF DEMO_FILE_PROP AYLA_FILE_PROP
  c include: ..\..\..\arch;..\..\..\arch\STM32F10x_StdPeriph_Driver\inc;..\..\..\lib\ayla\include;..\..\..\lib\ayla\config\include;..\..\..\lib\ayla\file_prop\include;..\..\..\lib\ayla\host_ota\include;..\..\..\lib\ayla\sched\include;..\..\..\lib\ayla\spi\include;..\..\..\lib\ayla\uart\include;..\..\..\example\file_prop;..\..\..\example\common;..\..\..\example\smart_ac;..\..\..\..\SEGGER_RTT\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0xe000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group sac
    ../../../example/common/: app_main.c app_property.c app_control.c app_uart.c
    ./../../../example/common/: app_protocol_i.c
    ../../../example/smart_ac/: sac_protocol_i.c sac_property.c sac_control.c
  group arch
    ../../../arch/: mcu_io.c spi_platform.c stm32.c uart_platform.c
  group ST
    ../../../arch/: system_stm32f10x.c
    C:/Keil/ARM/Startup/ST/STM32F10x/: startup_stm32f10x_md.s
    ../../../arch/STM32F10x_StdPeriph_Driver/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_spi.c stm32f10x_crc.c stm32f10x_flash.c stm32f10x_usart.c stm32f10x_tim.c
  group Ayla
    ../../../lib/ayla/: byte_order.c crc16.c props.c serial_msg.c tlv.c utf8.c
  group Ayla_demo
    ../../../example/file_prop/: demo_stream.c
    ../../../example/img_mgmt/: demo_img_mgmt.c
    ../../../example/wifi_mgmt/: wifi_demo.c
  group Ayla_config
    ../../../lib/ayla/config/: conf_access.c
  group Ayla_host_ota
    ../../../lib/ayla/host_ota/: host_ota.c
  group Ayla_sched
    ../../../lib/ayla/sched/: clock_utils.c sched.c schedeval.c
  group Ayla_file_prop
    ../../../lib/ayla/file_prop/: prop_dp.c
  group Ayla_spi
    ../../../lib/ayla/spi/: spi.c spi_ping.c
  group Ayla_uart
    ../../../lib/ayla/uart/: uart.c
