# Keil uVision project loader.uvproj, settings and files
target loader (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: loader
  c flags: Optim=1
  c define: STM32F10X_MD __NO_EMBEDDED_ASM USE_STDPERIPH_DRIVER AYLA_KEIL
  c include: ..\..\..\lib\ayla\include;..\..\..\arch;..\..\..\arch\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1c00
  memory RVCT9: RAM 0x20000000 size 0x800
  group loader
    ../../../arch/: loader.c
  group ST
    C:/Keil/ARM/Startup/ST/STM32F10x/: startup_stm32f10x_md.s system_stm32f10x.c
    ../../../arch/STM32F10x_StdPeriph_Driver/src/: stm32f10x_flash.c
  group keil
    ./: bb_entry.s
